* simulation de RC2
.control

noise v(n3) v1 dec 100 10k 1000k

write noise_binary.raw
.endc
.include RC2.net
