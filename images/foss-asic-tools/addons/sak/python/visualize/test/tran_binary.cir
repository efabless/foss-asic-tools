* simulation de RC2
.control

tran 10n 10000n

write tran_binary.raw
.endc
.include RC2.net
