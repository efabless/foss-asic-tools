* simulation de RC2
.control

dc v1 0 5 0.01

write
.endc
.include RC2.net
