**************************************
* SPICE STIMULI FILE
* generated from
**************************************

VLDA[5] LDA[5] 0 PWL 0n 0 161.4n 0 161.6n VCC 166.4n VCC 166.6n 0 177.4n
+0 177.6n VCC 182.4n VCC 182.6n 0 225.4n 0 225.6n VCC 230.4n VCC 230.6n 0
+257.4n 0 257.6n VCC 262.4n VCC 262.6n 0 305.4n 0 305.6n VCC 310.4n VCC 310.6n
+0 321.4n 0 321.6n VCC 326.4n VCC 326.6n 0 369.4n 0 369.6n VCC 374.4n VCC
+374.6n 0
VLDA[6] LDA[6] 0 PWL 0n 0 193.4n 0 193.6n VCC 198.4n VCC 198.6n 0 209.4n
+0 209.6n VCC 214.4n VCC 214.6n 0 225.4n 0 225.6n VCC 230.4n VCC 230.6n 0
+257.4n 0 257.6n VCC 262.4n VCC 262.6n 0 337.4n 0 337.6n VCC 342.4n VCC 342.6n
+0 353.4n 0 353.6n VCC 358.4n VCC 358.6n 0 369.4n 0 369.6n VCC 374.4n VCC
+374.6n 0
VLDEN LDEN 0 PWL 0n 0 129.4n 0 129.6n VCC 134.4n VCC 134.6n 0 145.4n
+0 145.6n VCC 150.4n VCC 150.6n 0 161.4n 0 161.6n VCC 166.4n VCC 166.6n 0
+177.4n 0 177.6n VCC 182.4n VCC 182.6n 0 193.4n 0 193.6n VCC 198.4n VCC 198.6n
+0 209.4n 0 209.6n VCC 214.4n VCC 214.6n 0 225.4n 0 225.6n VCC 230.4n VCC
+230.6n 0 241.4n 0 241.6n VCC 246.4n VCC 246.6n 0 257.4n 0 257.6n VCC 262.4n
+VCC 262.6n 0 273.4n 0 273.6n VCC 278.4n VCC 278.6n 0 289.4n 0 289.6n VCC
+294.4n VCC 294.6n 0 305.4n 0 305.6n VCC 310.4n VCC 310.6n 0 321.4n 0 321.6n
+VCC 326.4n VCC 326.6n 0 337.4n 0 337.6n VCC 342.4n VCC 342.6n 0 353.4n 0
+353.6n VCC 358.4n VCC 358.6n 0 369.4n 0 369.6n VCC 374.4n VCC 374.6n 0
VLDA[7] LDA[7] 0 PWL 0n 0 273.4n 0 273.6n VCC 278.4n VCC 278.6n 0 289.4n
+0 289.6n VCC 294.4n VCC 294.6n 0 305.4n 0 305.6n VCC 310.4n VCC 310.6n 0
+321.4n 0 321.6n VCC 326.4n VCC 326.6n 0 337.4n 0 337.6n VCC 342.4n VCC 342.6n
+0 353.4n 0 353.6n VCC 358.4n VCC 358.6n 0 369.4n 0 369.6n VCC 374.4n VCC
+374.6n 0
VLDCP LDCP 0 PWL 0n 0 131.9n 0 132.1n VCC 139.9n VCC 140.1n 0 147.9n
+0 148.1n VCC 155.9n VCC 156.1n 0 163.9n 0 164.1n VCC 171.9n VCC 172.1n 0
+179.9n 0 180.1n VCC 187.9n VCC 188.1n 0 195.9n 0 196.1n VCC 203.9n VCC 204.1n
+0 211.9n 0 212.1n VCC 219.9n VCC 220.1n 0 227.9n 0 228.1n VCC 235.9n VCC
+236.1n 0 243.9n 0 244.1n VCC 251.9n VCC 252.1n 0 259.9n 0 260.1n VCC 267.9n
+VCC 268.1n 0 275.9n 0 276.1n VCC 283.9n VCC 284.1n 0 291.9n 0 292.1n VCC
+299.9n VCC 300.1n 0 307.9n 0 308.1n VCC 315.9n VCC 316.1n 0 323.9n 0 324.1n
+VCC 331.9n VCC 332.1n 0 339.9n 0 340.1n VCC 347.9n VCC 348.1n 0 355.9n 0
+356.1n VCC 363.9n VCC 364.1n 0 371.9n 0 372.1n VCC 379.9n VCC 380.1n 0 387.9n
+0 388.1n VCC 395.9n VCC 396.1n 0
VLDOE LDOE 0 PWL 129.4n VCC 385.4n VCC 385.6n 0
VLDA[8] LDA[8] 0 PWL 0n 0 241.4n 0 241.6n VCC 246.4n VCC 246.6n 0
VLDA[10] LDA[10] 0 PWL 0n 0
VLDA[9] LDA[9] 0 PWL 0n 0
VLDA[11] LDA[11] 0 PWL 0n 0
VLDA[12] LDA[12] 0 PWL 0n 0
VVCC VCC 0 PWL 0n 0 15.9n 0 16.1n VCC
VLDA[0] LDA[0] 0 PWL 0n 0 145.4n 0 145.6n VCC 150.4n VCC 150.6n 0 177.4n
+0 177.6n VCC 182.4n VCC 182.6n 0 209.4n 0 209.6n VCC 214.4n VCC 214.6n 0
+241.4n 0 241.6n VCC 246.4n VCC 246.6n 0 257.4n 0 257.6n VCC 262.4n VCC 262.6n
+0 289.4n 0 289.6n VCC 294.4n VCC 294.6n 0 321.4n 0 321.6n VCC 326.4n VCC
+326.6n 0 353.4n 0 353.6n VCC 358.4n VCC 358.6n 0
VLDA[1] LDA[1] 0 PWL 0n 0 161.4n 0 161.6n VCC 166.4n VCC 166.6n 0 177.4n
+0 177.6n VCC 182.4n VCC 182.6n 0 225.4n 0 225.6n VCC 230.4n VCC 230.6n 0
+241.4n 0 241.6n VCC 246.4n VCC 246.6n 0 257.4n 0 257.6n VCC 262.4n VCC 262.6n
+0 305.4n 0 305.6n VCC 310.4n VCC 310.6n 0 321.4n 0 321.6n VCC 326.4n VCC
+326.6n 0 369.4n 0 369.6n VCC 374.4n VCC 374.6n 0
VLDA[2] LDA[2] 0 PWL 0n 0 193.4n 0 193.6n VCC 198.4n VCC 198.6n 0 209.4n
+0 209.6n VCC 214.4n VCC 214.6n 0 225.4n 0 225.6n VCC 230.4n VCC 230.6n 0
+241.4n 0 241.6n VCC 246.4n VCC 246.6n 0 257.4n 0 257.6n VCC 262.4n VCC 262.6n
+0 337.4n 0 337.6n VCC 342.4n VCC 342.6n 0 353.4n 0 353.6n VCC 358.4n VCC
+358.6n 0 369.4n 0 369.6n VCC 374.4n VCC 374.6n 0
VLDA[3] LDA[3] 0 PWL 0n 0 273.4n 0 273.6n VCC 278.4n VCC 278.6n 0 289.4n
+0 289.6n VCC 294.4n VCC 294.6n 0 305.4n 0 305.6n VCC 310.4n VCC 310.6n 0
+321.4n 0 321.6n VCC 326.4n VCC 326.6n 0 337.4n 0 337.6n VCC 342.4n VCC 342.6n
+0 353.4n 0 353.6n VCC 358.4n VCC 358.6n 0 369.4n 0 369.6n VCC 374.4n VCC
+374.6n 0
VLDA[4] LDA[4] 0 PWL 0n 0 145.4n 0 145.6n VCC 150.4n VCC 150.6n 0 177.4n
+0 177.6n VCC 182.4n VCC 182.6n 0 209.4n 0 209.6n VCC 214.4n VCC 214.6n 0
+257.4n 0 257.6n VCC 262.4n VCC 262.6n 0 289.4n 0 289.6n VCC 294.4n VCC 294.6n
+0 321.4n 0 321.6n VCC 326.4n VCC 326.6n 0 353.4n 0 353.6n VCC 358.4n VCC
+358.6n 0
