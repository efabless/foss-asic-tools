**************************************
* SPICE STIMULI FILE
* generated from
**************************************

VRSTF RSTF 0 PWL 0n 0 2n 0 2.1n VCC
VEN EN 0 PWL 2n 0 42n 0 42.1n VCC 82n VCC 82.1n 0 102n
+0 102.1n VCC 142n VCC 142.1n 0 162n 0 162.1n VCC 202n VCC 202.1n 0
+222n 0 222.1n VCC 262n VCC 262.1n 0
VVCC VCC 0 PWL 0n VCC
VCAL CAL 0 PWL 2n VCC 61.3n VCC 61.4n 0 82n 0 82.1n VCC 121.3n
+VCC 121.4n 0 142n 0 142.1n VCC 181.3n VCC 181.4n 0 202n 0 202.1n VCC
+241.3n VCC 241.4n 0 262n 0 262.1n VCC
VPLUS PLUS 0 PWL 2n 'VDL' 62n 'VDL' 66n 'VDL-0.002' 82n 'VDL-0.002' 82.1n 'VDL' 122n
+'VDL' 126n 'VDL+0.002' 142n 'VDL+0.002' 142.1n 'VDL'
VMINUS MINUS 0 PWL 2n 'VDL' 182n 'VDL' 186n 'VDL+0.002' 202n 'VDL+0.002' 202.1n 'VDL' 242n
+'VDL' 246n 'VDL-0.002' 262n 'VDL-0.002' 262.1n 'VDL'
VVSS VSS 0 PWL 0n 0
VLATCHF LATCHF 0 PWL 2n VCC 81n VCC 81.1n 0 82n 0 82.1n VCC 141n
+VCC 141.1n 0 142n 0 142.1n VCC 201n VCC 201.1n 0 202n 0 202.1n VCC
+261n VCC 261.1n 0 262n 0 262.1n VCC
