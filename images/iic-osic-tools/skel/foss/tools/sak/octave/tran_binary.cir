* simulation de RC2
.control

tran 10n 10000n

write
.endc
.include RC2.net
