* simulation de RC2
.control
set filetype=ascii
tran 10n 10000n
ac dec 100 10k 1000k
dc v1 0 5 0.01

write complicated_ascii.raw ac.v(n0) ac.v(n1) ac.v(n2) dc.v(n1) dc.v(n2) tran.v(n1)
.endc
.include RC2.net
