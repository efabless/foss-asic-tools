* simulation de RC2
.control
set filetype=ascii
ac dec 100 10k 1000k

write ac_ascii.raw
.endc
.include RC2.net
