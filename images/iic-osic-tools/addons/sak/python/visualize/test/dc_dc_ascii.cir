* simulation de RC2
.control
set filetype=ascii
dc v1 0 5 0.1 i1 0 5mA 1mA

write dc_dc_ascii.raw
.endc
.include RC2.net
