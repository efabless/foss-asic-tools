* simulation de RC2
.control
set filetype=ascii
tran 10n 10000n

write
.endc
.include RC2.net
